# Keil uVision project template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: .\inc;.\lib\api\inc;.\lib\cmsis\inc;.\lib\system\inc;.\lib\misc\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ./lib/system/src/: startup_stm32f103xb.S system_stm32f1xx.c stm32f1xx_it.c
  group cmsis
    ./lib/cmsis/inc/: cmsis.h cmsis_nvic.h core_cm3.h
  group api
    ./lib/api/src/: Common.c CircularBuffer.cpp Delay.c GPIO.cpp Digital.cpp
  group user
    ./src/: main.c
